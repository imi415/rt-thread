# Keil uVision project project.uvprojx, settings and files
target rtthread-frdm-mcxn947 (6190000::V6.19::ARMCLANG)
  device: MCXN947VDF:cm33_core0 NXP
  pack: NXP.MCXN947_DFP.17.0.0
  cpu: IRAM(0x20000000,0x060000) IRAM2(0x20060000,0x8000) IROM(0x03000000,0x040000) IROM2(0x13000000,0x040000) XRAM(0x30060000,0x8000) XRAM2(0x04000000,0x018000) XRAM3(0x14000000,0x018000) XROM(0x00000000,0x100000) XROM2(0x00100000,0x100000) XROM3(0x10000000,0x100000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: rtthread
  c flags: OneElfS=1 uC99=1 wLevel=3
  c define: RT_USING_ARMLIBC, DEBUG, RT_USING_LIBC, CPU_MCXN947VDF_cm33_core0, __STDC_LIMIT_MACROS, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c misc: --target=arm-arm-none-eabi
  c include: ..\..\..\..\..\libcpu\arm\common;..\..\..\..\..\include;..\..\..\..\..\components\net\sal\impl;..\..\..\..\..\components\dfs\dfs_v1\filesystems\tmpfs;..\..\..\..\..\components\net\lwip\lwip-2.0.3\src\include\netif;..\Libraries\CMSIS\Core\Include;..\..\..\..\..\components\libc\posix\io\epoll;..\..\..\..\..\components\net\sal\include\socket;..\..\..\..\..\components\drivers\spi;board\MCUX_Config\board;..\..\..\..\..\components\dfs\dfs_v1\include;..\..\..\..\..\components\drivers\include;..\Libraries\MCXN947\MCXN947\drivers\romapi\flash;packages\zlib-latest\src;.;applications\include;..\..\..\..\..\components\dfs\dfs_v1\filesystems\romfs;..\Libraries\MCXN947\MCXN947\drivers\romapi\runbootloader;..\..\..\..\..\components\libc\posix\io\eventfd;..\..\..\..\..\components\dfs\dfs_v1\filesystems\devfs;..\..\..\..\..\components\drivers\wlan;board;..\..\..\..\..\components\libc\compilers\common\include;packages\webnet-latest\inc;..\..\..\..\..\components\libc\posix\ipc;..\..\..\..\..\components\libc\compilers\common\extension;..\..\..\..\..\components\net\lwip\lwip-2.0.3\src\include\ipv4;..\..\..\..\..\libcpu\arm\cortex-m33;..\..\..\..\..\components\libc\posix\io\poll;..\Libraries\MCXN947\MCXN947;..\..\..\..\..\components\net\sal\include\dfs_net;..\Libraries\MCXN947\MCXN947\drivers\romapi\mem_interface;..\..\..\..\..\components\drivers\include;packages\rw007-v2.1.0\inc;..\..\..\..\..\components\dfs\dfs_v1\filesystems\ramfs;..\..\..\..\..\components\net\netdev\include;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\net\sal\include;..\..\..\..\..\components\finsh;..\Libraries\MCXN947\MCXN947\drivers\romapi\nboot;..\..\..\..\..\components\net\sal\include\socket\sys_socket;..\..\..\..\..\components\utilities\ulog;applications;..\Libraries\drivers;..\..\..\..\..\components\net\lwip\lwip-2.0.3\src\include;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\drivers\spi\sfud\inc;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\dfs\dfs_v1\filesystems\elmfat;..\..\..\..\..\components\net\lwip\port;packages\rw007-v2.1.0;packages\cJSON-v1.7.17;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\..\..\components\drivers\include;..\Libraries\drivers\config;..\Libraries\MCXN947\MCXN947\drivers
  asm misc: -x assembler-with-cpp
  memory RVCT1: ROM 0x0 size 0x100000
  memory RVCT2: ROM 0x100000 size 0x100000
  memory RVCT3: ROM 0x10000000 size 0x100000
  memory RVCT4: ROM 0x3000000 size 0x40000
  memory RVCT5: ROM 0x13000000 size 0x40000
  memory RVCT6: RAM 0x30060000 size 0x8000
  memory RVCT7: RAM 0x4000000 size 0x18000
  memory RVCT8: RAM 0x14000000 size 0x18000
  memory RVCT9: RAM 0x20000000 size 0x60000
  memory RVCT10: RAM 0x20060000 size 0x8000
  scatter file: .\board\linker_scripts\MCXN947_cm33_core0_flash.scf
  group Applications
    applications/: app_romfs.c app_camera.c app_webserver.c main.c
  group cJSON
    packages/cJSON-v1.7.17/: cJSON_Utils.c cJSON.c
  group Compiler
    ../../../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../../../components/drivers/core/: device.c
    ../../../../../components/drivers/hwtimer/: hwtimer.c
    ../../../../../components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    ../../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../../components/drivers/mtd/: mtd_nor.c
    ../../../../../components/drivers/pin/: pin.c
    ../../../../../components/drivers/serial/: serial.c
    ../../../../../components/drivers/spi/: qspi_core.c spi_core.c spi_dev.c spi_flash_sfud.c
    ../../../../../components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../../../../components/drivers/wlan/: wlan_cfg.c wlan_cmd.c wlan_dev.c wlan_lwip.c wlan_mgnt.c wlan_prot.c wlan_workqueue.c
  group Drivers
    board/MCUX_Config/board/: clock_config.c pin_mux.c
    board/: board.c
    board/ports/: drv_filesystem_spi_flash.c drv_spi_sample_rw007.c
    ../Libraries/drivers/: drv_i2c.c drv_pin.c drv_qspi_flexspi.c drv_spi.c drv_uart.c
  group Filesystem
    ../../../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../../../components/dfs/dfs_v1/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    ../../../../../components/dfs/dfs_v1/filesystems/ramfs/: dfs_ramfs.c
    ../../../../../components/dfs/dfs_v1/filesystems/romfs/: dfs_romfs.c
    ../../../../../components/dfs/dfs_v1/filesystems/tmpfs/: dfs_tmpfs.c
    ../../../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../../../components/finsh/: cmd.c shell.c msh_file.c msh.c msh_parse.c
  group Kernel
    ../../../../../src/: clock.c components.c cpu_up.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../../../../src/klibc/: kstdio.c kstring.c
  group libcpu
    ../../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../../libcpu/arm/cortex-m33/: context_rvds.S cpuport.c syscall_rvds.S trustzone.c
  group Libraries
    ../Libraries/MCXN947/MCXN947/drivers/: fsl_irtc.c fsl_pwm.c fsl_powerquad_data.c fsl_i3c.c fsl_lpuart_edma.c fsl_common_arm.c fsl_powerquad_basic.c fsl_flexio_mculcd_smartdma.c fsl_cache_lpcac.c fsl_ctimer.c fsl_qdc.c fsl_intm.c fsl_sema42.c fsl_clock.c fsl_flexio_uart_edma.c fsl_lpflexcomm.c fsl_sai.c fsl_smartdma_mcxn.c fsl_flexcan_edma.c fsl_ostimer.c fsl_spc.c fsl_smartdma.c fsl_flexio_uart.c fsl_lptmr.c fsl_tdet.c fsl_trdc.c fsl_cmc.c fsl_lpspi_edma.c fsl_pint.c fsl_itrc.c fsl_tsi_v6.c fsl_enet.c fsl_pdm_edma.c fsl_flexio_i2c_master.c fsl_dac.c fsl_flexcan.c fsl_freqme.c fsl_reset.c fsl_common.c fsl_flexio_mculcd_edma.c fsl_sai_edma.c fsl_smartcard_phy_emvsim.c fsl_lpspi.c fsl_edma.c fsl_mrt.c fsl_plu.c fsl_opamp.c fsl_cache.c fsl_power.c fsl_crc.c fsl_pdm.c fsl_syspm.c fsl_edma_soc.c fsl_dac14.c fsl_powerquad_math.c fsl_wuu.c fsl_lpuart.c fsl_smartdma_rt500.c fsl_i3c_edma.c fsl_powerquad_filter.c fsl_flexspi.c fsl_flexio_spi_edma.c fsl_lpadc.c fsl_erm.c fsl_powerquad_transform.c fsl_vref.c fsl_lpi2c_edma.c fsl_powerquad_matrix.c fsl_gpio.c fsl_flexio_spi.c fsl_sinc.c fsl_cdog.c fsl_gdet.c fsl_flexio_mculcd.c fsl_eim.c fsl_flexspi_edma.c fsl_inputmux.c fsl_lpcmp.c fsl_lpi2c.c fsl_wwdt.c fsl_usdhc.c fsl_vbat.c fsl_sctimer.c fsl_puf_v3.c fsl_smartcard_emvsim.c fsl_flexio.c fsl_evtg.c fsl_ewm.c fsl_utick.c
    ../Libraries/MCXN947/MCXN947/arm/: startup_MCXN947_cm33_core0.s
    ../Libraries/MCXN947/MCXN947/: system_MCXN947_cm33_core0.c
    ../Libraries/MCXN947/MCXN947/drivers/romapi/nboot/src/: fsl_nboot.c
    ../Libraries/MCXN947/MCXN947/drivers/romapi/mem_interface/src/: fsl_mem_interface.c
    ../Libraries/MCXN947/MCXN947/drivers/romapi/flash/src/: fsl_flash.c
    ../Libraries/MCXN947/MCXN947/drivers/romapi/runbootloader/src/: fsl_runbootloader.c
  group lwIP
    ../../../../../components/net/lwip/lwip-2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../../components/net/lwip/lwip-2.0.3/src/apps/ping/: ping.c
    ../../../../../components/net/lwip/lwip-2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../../../components/net/lwip/lwip-2.0.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../../../components/net/lwip/lwip-2.0.3/src/netif/: ethernet.c lowpan6.c
    ../../../../../components/net/lwip/port/: ethernetif.c sys_arch.c
  group POSIX
    ../../../../../components/libc/posix/io/poll/: poll.c select.c
  group rt_kprintf
    packages/rt_vsnprintf_full-latest/: rt_vsnprintf.c
  group rw007
    packages/rw007-v2.1.0/src/: spi_wifi_rw007.c
  group SAL
    ../../../../../components/net/netdev/src/: netdev.c netdev_ipaddr.c
    ../../../../../components/net/sal/dfs_net/: dfs_net.c
    ../../../../../components/net/sal/impl/: af_inet_lwip.c
    ../../../../../components/net/sal/socket/: net_netdb.c net_sockets.c
    ../../../../../components/net/sal/src/: sal_socket.c
  group Utilities
    ../../../../../components/utilities/ulog/: ulog.c
    ../../../../../components/utilities/ulog/backend/: console_be.c
  group WebNet
    packages/webnet-latest/src/: wn_mimetype.c wn_utils.c wn_request.c webnet.c wn_module.c wn_session.c
    packages/webnet-latest/module/: wn_module_index.c wn_module_cgi.c
  group zlib
    packages/zlib-latest/src/: compress.c gzread.c gzclose.c inflate.c zutil.c inffast.c crc32.c gzwrite.c inftrees.c uncompr.c gzlib.c adler32.c deflate.c infback.c trees.c
